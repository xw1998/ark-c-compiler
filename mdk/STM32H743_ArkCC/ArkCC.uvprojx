# Keil uVision project ArkCC.uvprojx, settings and files
target ArkCC_H743 (5060000::V5.06::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(480000000) ELITTLE
  output: ArkCC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,ARK_TARGET_STM32H7,ARKCC_PROFILE=ARKCC_PROFILE_STM32_MIN
  c include: ..\..\include;..\..\stdlib\include;.\User\Inc;.\Drivers\CMSIS\Device\ST\STM32H7xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32H7xx_HAL_Driver\Inc;.\RTE\_ArkCC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: .\Linker\STM32H743VITx_FLASH.sct
  group Application/User
    ./User/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c system_stm32h7xx.c bsp_w25q.c bsp_sdram.c
  group Application/Startup
    ./Startup/: startup_stm32h743xx.s
  group ArkCC/Core
    ../../src/: compiler.c diag.c diag_msg_table.c lexer.c parser.c sema.c ir.c irgen.c ast.c agginit.c type.c symtab.c memory.c preproc.c codegen_common.c cpu.c config.c opt.c pipeline.c ipo.c irser.c scatter.c
  group ArkCC/Backend
    ../../src/backend/: registry.c
    ../../src/backend/arm/: backend_arm.c
  group ArkCC/Port
    ../../port/stm32/: platform_stm32.c flash_fs_stm32.c
